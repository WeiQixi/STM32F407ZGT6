# Keil uVision project TOUCH.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4xx_HAL_Driver\inc;..\USER\LED;..\USER\LCD;..\USER\BEEP;..\USER\KEY;..\USER\LCD;..\USER\TOUCH
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c stm32f4xx_hal_msp.c startup_stm32f407xx.s cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group USER
    ../USER/LED/: led.c
    ../USER/BEEP/: beep.c
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/TOUCH/: ft5426.c touch.c xpt2046.c
  group STM32F4_HAL_FWLIB
    ../STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c
  group Common
    ../Common/: common.c
software components: CMSIS:CORE 4.3.0
