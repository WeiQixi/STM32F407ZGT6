# Keil uVision project TOUCH.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\KEY;..\USER\LCD;..\USER\LED;..\USER\TOUCH;..\USER\usart1;..\USER\KEY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group USER
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/LED/: led.c
    ../USER/usart1/: usart1.c
  group TOUCH
    ../USER/TOUCH/: touch.c xpt2046.c ft5426.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c
  group Common
    ../Common/: common.c
software components: CMSIS:CORE 4.3.0
