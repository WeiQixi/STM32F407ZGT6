# Keil uVision project R_LCD_FreeRTOS_LVGL_demo.uvprojx, settings and files
target R_LCD_FreeRTOS_LVGL_demo (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: R_LCD_FreeRTOS_LVGL_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,MY_DISP_HOR_RES=320,MY_DISP_VER_RES=240,LV_LVGL_H_INCLUDE_SIMPLE=1
  c misc: --diag_suppress=188,111,1293
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/Inc;../FreeRTOS/portable/ARM_CM4F;..\HardWare\lcd;..\LVGL;..\LVGL\src;..\LVGL\examples\porting;..\LVGL\demos;..\LVGL\demos\stress;..\LVGL\demos\music\assets;..\LVGL\demos\music\assets
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: common.c main.c fsmc.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c DWT_delay.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeRTOS/Portable/ARM_CM4F
    ../FreeRTOS/portable/ARM_CM4F/: port.c
  group FreeRTOS/Portable/Heap
    ../FreeRTOS/portable/heap/: heap_4.c
  group FreeRTOS/Src
    ../FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Application/User/HardWare/lcd
    ../HardWare/lcd/: lcd.c cfont.c touch.c xpt2046.c
  group LVGL/Config
    ../LVGL/: lv_conf.h lv_version.h lvgl.h lvgl_private.h
  group LVGL/Porting
    ../LVGL/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c lv_port_lcd_stm32.c
  group LVGL/src
    ../LVGL/src/: lv_init.c
  group LVGL/src/core
    ../LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
  group LVGL/src/Display
    ../LVGL/src/display/: lv_display.c
  group LVGL/src/Draw
    ../LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group LVGL/src/Indev
    ../LVGL/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group LVGL/src/Layouts
    ../LVGL/src/layouts/: lv_layout.c
    ../LVGL/src/layouts/grid/: lv_grid.c
    ../LVGL/src/layouts/flex/: lv_flex.c
  group LVGL/src/Misc
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
  group LVGL/src/Osal
    ../LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group LVGL/src/Stdlib
    ../LVGL/src/stdlib/: lv_mem.c
    ../LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group LVGL/src/Themes
    ../LVGL/src/themes/: lv_theme.c
    ../LVGL/src/themes/default/: lv_theme_default.c
    ../LVGL/src/themes/simple/: lv_theme_simple.c
    ../LVGL/src/themes/mono/: lv_theme_mono.c
  group LVGL/src/Tick
    ../LVGL/src/tick/: lv_tick.c
  group LVGL/src/Widgets
    ../LVGL/src/widgets/animimage/: lv_animimage.c
    ../LVGL/src/widgets/arc/: lv_arc.c
    ../LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../LVGL/src/widgets/bar/: lv_bar.c
    ../LVGL/src/widgets/button/: lv_button.c
    ../LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../LVGL/src/widgets/canvas/: lv_canvas.c
    ../LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/widgets/chart/: lv_chart.c
    ../LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../LVGL/src/widgets/image/: lv_image.c
    ../LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/widgets/label/: lv_label.c
    ../LVGL/src/widgets/led/: lv_led.c
    ../LVGL/src/widgets/line/: lv_line.c
    ../LVGL/src/widgets/list/: lv_list.c
    ../LVGL/src/widgets/switch/: lv_switch.c
    ../LVGL/src/widgets/menu/: lv_menu.c
    ../LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/widgets/roller/: lv_roller.c
    ../LVGL/src/widgets/scale/: lv_scale.c
    ../LVGL/src/widgets/slider/: lv_slider.c
    ../LVGL/src/widgets/span/: lv_span.c
    ../LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/widgets/spinner/: lv_spinner.c
    ../LVGL/src/widgets/table/: lv_table.c
    ../LVGL/src/widgets/tabview/: lv_tabview.c
    ../LVGL/src/widgets/textarea/: lv_textarea.c
    ../LVGL/src/widgets/tileview/: lv_tileview.c
    ../LVGL/src/widgets/win/: lv_win.c
  group LVGL/src/Fonts
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c
  group LVGL/demo
    ../LVGL/demos/: lv_demos.c
    ../LVGL/demos/stress/: lv_demo_stress.c
    ../LVGL/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group LVGL/demo/music/assets
    ../LVGL/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
software components: CMSIS:CORE 6.1.0
